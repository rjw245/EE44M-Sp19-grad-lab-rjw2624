# Keil uVision project lab-5-rjw2624_jj37297.uvproj, settings and files
target ST7735 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: lab2 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ./inc/
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./src/: PLL.c ST7735.c startup.s ADC.c UART.c interpreter.c OS.c OS_asm.s assert.s Switch.c profiler.c timeMeasure.c Lab4.c cr4_fft_64_stm32.s diskio.c ff.c heap.c loader.c
  group Include
    ./inc/: asmdefs.h hw_adc.h hw_aes.h hw_can.h hw_ccm.h hw_comp.h hw_des.h hw_eeprom.h hw_emac.h hw_epi.h hw_ethernet.h hw_fan.h hw_flash.h hw_gpio.h hw_hibernate.h hw_i2c.h hw_i2s.h hw_ints.h hw_lcd.h hw_lpc.h hw_memmap.h hw_nvic.h hw_peci.h hw_pwm.h hw_qei.h hw_shamd5.h hw_ssi.h hw_sysctl.h hw_sysexc.h hw_timer.h hw_types.h hw_uart.h hw_udma.h hw_usb.h hw_watchdog.h PLL.h ST7735.h tm4c123gh6pm.h ADC.h UART.h OS.h FIFO.h misc_macros.h Switch.h profiler.h timeMeasure.h diskio.h ff.h heap.h ffconf.h integer.h loader_config.h loader.h elf.h
