# Keil uVision project gradlab-rjw2624_jj37297.uvproj, settings and files
target ST7735 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: lab2 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ./inc/;./lib/VL53L0X/VL53L0X/inc;./lib/VL53L0X/core/inc;./lib/VL53L0X/platform/inc;./lib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./src/: PLL.c ST7735.c startup.s ADC.c UART.c interpreter.c OS.c OS_asm.s assert.s Switch.c profiler.c timeMeasure.c cr4_fft_64_stm32.s diskio.c ff.c heap.c loader.c lidar.c I2C.c IR.c motors.c can.c can0.c interrupt.c memprotect.c main.c
  group Include
    ./inc/: PLL.h ST7735.h tm4c123gh6pm.h ADC.h UART.h OS.h FIFO.h misc_macros.h Switch.h profiler.h timeMeasure.h diskio.h ff.h heap.h ffconf.h integer.h loader_config.h loader.h elf.h lidar.h I2C.h IR.h motors.h can.h can0.h interrupt.h memprotect.h
  group Library
    ./lib/VL53L0X/core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
    ./lib/VL53L0X/platform/src/: vl53l0x_platform.c
    ./lib/VL53L0X/VL53L0X/src/: VL53L0X.c VL53L0X_I2C.c xshut.c
